<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\my_projects.ewp</path>
    </project>
    <batchBuild />
</workspace>
