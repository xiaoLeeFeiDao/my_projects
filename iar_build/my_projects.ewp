# IAR project my_projects.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CortexM7MPS2FVP Cortex-M7 MPS2 FVP
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCIncludePath2: D:\code\my_projects\lib\securec\include; D:\code\my_projects\src\cpp_case\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: my_projects.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 1
  group (top)
    ./: main.cpp
  group cpp_case/include
    ../src/cpp_case/include/: test.h
  group cpp_case/src
    ../src/cpp_case/src/: 01_c++书写HelloWorld.cpp 02_双冒号作用域运算符.cpp 11_引用--参数的传递方式.cpp 12_指针的引用.cpp 13_常量的引用.cpp 14_内联函数.cpp 15_函数的默认参数及占位参数.cpp 16_函数的重载.cpp 17_封装.cpp 18_构造和析构.cpp 19_构造函数的调用规则.cpp 20_深拷贝和浅拷贝.cpp 21_初始化列表.cpp 22_类对象作为类成员.cpp 23_new运算符.cpp 24_静态变量成员属性.cpp 25_单例模式.cpp 26_打印机单例模式.cpp 27_对象模型初探.cpp 28_this指针.cpp 29_空指针访问成员函数.cpp 30_常函数和常对象.cpp 31_友元函数.cpp 32_加号运符重载.cpp 33_递增运算符重载.cpp 34_指针运算符的重载.cpp 35_赋值运算符重载.cpp 36_关系运算符重载.cpp 37_函数调用运算符重载.cpp 38_继承.cpp 39_继承中的对象模型.cpp 40_继承中的构造和析构.cpp 41_继承中的同名成员处理.cpp 42_继承中静态成员的处理.cpp 43_多继承的概念以及问题.cpp 44_菱形继承与虚继承.cpp eg1_设计一个类，求圆的周长.cpp eg2_设计一个学生类.cpp eg3_设置一个person类-属性方法访问权限.cpp eg4_set_cube_class.cpp eg5_judgeRelationCirclePoint.cpp eg6_package_array_class.cpp eg6_package_array_class.h eg7_package_string_class.cpp eg7_package_string_class.h game1.cpp game1.h game2.cpp game2.h game_push_boxes.cpp namespace.cpp namespace.h test.cpp
